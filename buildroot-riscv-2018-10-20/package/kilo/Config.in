## buildroot-riscv-2018-10-20/package/kilo/Config.in
```kconfig
config BR2_PACKAGE_KILO
	bool "kilo"
	help
	  This is simple editor kilo.

	  https://github.com/sysprog21/kilo
```
